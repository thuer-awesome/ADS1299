# Keil uVision project PEIKI.uvprojx, settings and files
target PEIKI (5060528::V5.06 update 5 (build 528)::ARMCC)
  device: STM32F103C8 STMicroelectronics
  pack: Keil.STM32F1xx_DFP.2.3.0
  cpu: IRAM(0x20000000,0x00005000) IROM(0x08000000,0x00010000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: STM32F103C8T6 +hex
  c flags: v6Lang=1 v6LangP=1
  c define: STM32F10X_MD,USE_STDPERIPH_DRIVER
  c include: ..\USER;..\STM32F10x_FWLib\inc;..\SYSTEM;..\Hardware;..\ADS129x;..\M8266WIFI
  memory RVCT4: ROM 0x8000000 size 0x10000
  memory RVCT9: RAM 0x20000000 size 0x5000
  group SYSTEM
    ../SYSTEM/: core_cm3.c system_stm32f10x.c stm32f10x_it.c startup_stm32f10x_md.s startup_stm32f10x_hd.s
  group FWLib
    ../STM32F10x_FWLib/src/: misc.c stm32f10x_gpio.c stm32f10x_rcc.c stm32f10x_usart.c stm32f10x_exti.c stm32f10x_adc.c stm32f10x_dma.c stm32f10x_i2c.c stm32f10x_spi.c stm32f10x_tim.c stm32f10x_bkp.c stm32f10x_can.c stm32f10x_cec.c stm32f10x_crc.c stm32f10x_dac.c stm32f10x_dbgmcu.c stm32f10x_flash.c stm32f10x_fsmc.c stm32f10x_iwdg.c stm32f10x_pwr.c stm32f10x_rtc.c stm32f10x_sdio.c stm32f10x_wwdg.c
  group USER
    ./: sys.c main.c
  group HARDWARE
    ../Hardware/: delay.c usart.c key.c spi.c Timer.c led.c malloc.c dma.c adc.c BG22AX.c stmflash.c myQueue.c OPENBCI.c
  group ADS129X
    ../ADS129x/: ADS129x.C
