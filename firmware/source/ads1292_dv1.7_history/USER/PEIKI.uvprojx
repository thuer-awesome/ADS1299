# Keil uVision project PEIKI.uvprojx, settings and files
target PEIKI (5060528::V5.06 update 5 (build 528)::ARMCC)
  device: STM32L432KBUx STMicroelectronics
  pack: Keil.STM32L4xx_DFP.2.3.0
  cpu: IRAM(0x20000000,0x0000C000) IRAM2(0x10000000,0x00004000) IROM(0x08000000,0x00020000) CPUTYPE("Cortex-M4") FPU2 DSP CLOCK(12000000) ELITTLE
  output: STM32_DEMO +hex
  c flags: Optim=1 OneElfS=1 uC99=1 v6Lang=1 v6LangP=1
  c define: USE_HAL_DRIVER,STM32L432xx
  c include: ..\USER;..\HALLIB\STM32L4xx_HAL_Driver\Inc;..\HALLIB\STM32L4xx_HAL_Driver\Inc\Legacy;..\HALLIB\STM32F4xx_HAL_Driver\Inc;..\HALLIB\STM32F4xx_HAL_Driver\Inc\Legacy;..\CORE;..\Hardware;..\ADS129x;..\FATFS\exfuns;..\FATFS\src;..\FATFS\src\option
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x20000
  memory RVCT9: RAM 0x20000000 size 0xc000
  memory RVCT10: RAM 0x10000000 size 0x4000
  group STM32L4_HALLIB
    ../HALLIB/STM32L4xx_HAL_Driver/Src/: stm32l4xx_hal.c stm32l4xx_hal_cortex.c stm32l4xx_hal_gpio.c stm32l4xx_hal_pwr.c stm32l4xx_hal_pwr_ex.c stm32l4xx_hal_rcc.c stm32l4xx_hal_rcc_ex.c stm32l4xx_hal_uart.c stm32l4xx_hal_uart_ex.c stm32l4xx_hal_usart.c stm32l4xx_hal_usart_ex.c stm32l4xx_hal_dma.c stm32l4xx_hal_dma_ex.c stm32l4xx_hal_tim.c stm32l4xx_hal_tim_ex.c stm32l4xx_hal_adc.c stm32l4xx_hal_adc_ex.c stm32l4xx_hal_spi.c stm32l4xx_hal_spi_ex.c stm32l4xx_hal_rtc.c stm32l4xx_hal_rtc_ex.c stm32l4xx_hal_wwdg.c
  group SYSTEM
    ../CORE/: stm32l4xx_hal_conf.h system_stm32l4xx.c stm32l4xx_it.c startup_stm32l432xx.s
  group HARDWARE
    ../Hardware/: sys.c delay.c malloc.c nvic.c led.c key.c usart.c Timer.c spi.c adc.c dma.c wkup.c myQueue.c RF4404B4.c BG22AX.c MYFATFS.c sd_card.c fatfs.c
  group USER
    ./: main.c
  group FATFS
    ../FATFS/exfuns/: exfuns.c fattester.c
    ../FATFS/src/: diskio.c ff.c
    ../FATFS/src/option/: mycc936.c
  group ADS129X
    ../ADS129x/: ADS129x.C
